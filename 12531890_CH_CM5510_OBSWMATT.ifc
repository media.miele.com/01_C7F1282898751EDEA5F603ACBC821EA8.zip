Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-12-05T09:17:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 05 09:17:23 2023 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\086b9cfc-e090-42d1-b323-10fbb453237f\89f5a196-b045-414c-ab59-732c3935b932\ifc * Database version: 5507 * Database creation date: Tue Dec 05 09:17:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 05 09:17:23 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 05 09:17:23 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12531890_CH_CM5510_OBSWMATT:29551021_CH_12531890_CM5510_OBSWMATT, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 29551021_CH_12531890_CM5510_OBSWMATT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 29551021_CH_12531890_CM5510_OBSWMATT
Type - Pset_ProvisionForVoid - Width: 251 mm; Height: 359 mm; Depth: 427 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
